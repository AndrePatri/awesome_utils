Commit message: added random configuration test

File: tests/urdf/quadruped.urdf (robot description, URDF)
Before this commit: robot quadruped, 113 links, 112 joints
Joints:
- removed joint reference
- added joint world_joint: type floating, parent world, child pelvis
